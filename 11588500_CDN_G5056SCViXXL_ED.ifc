Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-03-13T17:07:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 13 17:07:32 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1a7ec204-b855-42cc-ae0d-65669df4b092\2c688bdc-5c11-4e3c-ba90-1fcbf545398c\ifc * Database version: 5507 * Database creation date: Mon Mar 13 17:07:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 13 17:07:32 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 13 17:07:32 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11588500_CDN_G5056SCViXXL_ED:21505662_CDN_11588500_G5056SCViXXL_ED, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 21505662_CDN_11588500_G5056SCViXXL_ED
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 21505662_CDN_11588500_G5056SCViXXL_ED
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 855 mm; Depth: 550 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_OBSW, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_357483
Description: Flow; FlowDirection: SOURCEANDSINK
